# Keil uVision project 8051HB.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC848 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: 8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source;.\source\Mode
  asm include: .\asm;..\【170404】秒表
  group Main
    ./asm/: main.asm
